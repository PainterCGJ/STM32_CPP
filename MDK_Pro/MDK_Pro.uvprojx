# Keil uVision project MDK_Pro.uvprojx, settings and files
target STM32_CPP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,USE_OS
  c misc: --cpp11
  c include: ..\Code\CMSIS;..\Code\Application\inc;..\Code\BSP\delay;..\Code\BSP\sys;..\Code\Interface\inc;..\Code\STM32F10x_StdPeriph_Driver\inc;..\Code\FreeRTOS;..\Code\FreeRTOS\inc;..\Code\FreeRTOS\port\RVDS\ARM_CM3;..\Code\BSP\sys;..\Code\BSP\uart;..\Code\BSP\timer;..\Code\BSP;..\Code\BSP\systick;..\Code\BSP\rtos
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Code/Application/src/: main.cpp
  group CMSIS
    ../Code/CMSIS/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s core_cm3.c
  group Driver
    ../Code/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS/port
    ../Code/FreeRTOS/port/MemMang/: heap_4.c
    ../Code/FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group FreeRTOS/src
    ../Code/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group BSP
    ../Code/BSP/sys/: sys_bsp.cpp
    ../Code/BSP/uart/: stm32f10x_uart_bsp.cpp
    ../Code/BSP/timer/: stm32f10x_timer_bsp.cpp
    ../Code/BSP/systick/: stm32f10x_systick_bsp.cpp
    ../Code/BSP/rtos/: rtos_bsp.cpp
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
